# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Core;..\Main;..\Driver;..\SDK\CMSIS\Include;..\SDK\CMSIS\Device\ST\STM32F1xx\Include;..\SDK\STM32F1xx_HAL_Driver\Src;..\SDK\STM32F1xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../Main/: main.c
  group Driver
    ../Driver/: driver_led.c driver_led.h driver_key.c driver_key.h
  group Core
    ../Core/: startup_stm32f103xe.s stm32f1xx_clk.c stm32f1xx_it.c stm32f1xx_hal_conf.h system_stm32f1xx.c
  group SDK
    ../SDK/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c
